# Keil uVision project DemoUart.uvprojx, settings and files
target DemoUart (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DemoUart +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../: main.c stm32f10x_it.c STM32vldiscovery.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
